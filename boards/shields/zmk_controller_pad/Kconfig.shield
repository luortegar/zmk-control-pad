## boards/shields/zmk_controller_pad/Kconfig.shield
```kconfig
config SHIELD_ZMK_CONTROLLER_PAD
    def_bool $(shields_list_contains,zmk_controller_pad)
```
